VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO BLK1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 120 BY 60 ;
  SYMMETRY X Y R90 ;
END BLK1

MACRO BLK2
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 90 BY 90 ;
  SYMMETRY X Y R90 ;
END BLK2

END LIBRARY
