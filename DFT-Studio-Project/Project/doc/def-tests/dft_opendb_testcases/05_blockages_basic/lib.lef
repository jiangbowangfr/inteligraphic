VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CORE
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 80 BY 80 ;
  SYMMETRY X Y R90 ;
END CORE

MACRO MEM
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 200 BY 120 ;
  SYMMETRY X Y R90 ;
END MEM

END LIBRARY
