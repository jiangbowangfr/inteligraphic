VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO BLK
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 120 BY 120 ;
  SYMMETRY X Y R90 ;
END BLK

MACRO TILE
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 60 BY 40 ;
  SYMMETRY X Y R90 ;
END TILE

END LIBRARY
