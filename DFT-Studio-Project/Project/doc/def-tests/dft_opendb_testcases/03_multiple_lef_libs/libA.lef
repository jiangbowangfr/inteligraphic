VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO A1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 50 BY 40 ;
  SYMMETRY X Y R90 ;
END A1

MACRO A2
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 70 BY 20 ;
  SYMMETRY X Y R90 ;
END A2

END LIBRARY
