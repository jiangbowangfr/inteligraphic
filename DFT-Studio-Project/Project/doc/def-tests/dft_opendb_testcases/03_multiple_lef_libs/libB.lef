VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO B1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 90 BY 90 ;
  SYMMETRY X Y R90 ;
END B1

MACRO B2
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 110 BY 30 ;
  SYMMETRY X Y R90 ;
END B2

END LIBRARY
