VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO DSP
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 160 BY 100 ;
  SYMMETRY X Y R90 ;
END DSP

MACRO SRAM
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 250 BY 180 ;
  SYMMETRY X Y R90 ;
END SRAM

MACRO CTRL
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 80 BY 50 ;
  SYMMETRY X Y R90 ;
END CTRL

END LIBRARY
