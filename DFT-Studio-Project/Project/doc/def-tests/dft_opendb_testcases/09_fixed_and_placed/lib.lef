VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO FIXBLK
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 150 BY 150 ;
  SYMMETRY X Y R90 ;
END FIXBLK

MACRO PLCBLK
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 100 BY 40 ;
  SYMMETRY X Y R90 ;
END PLCBLK

END LIBRARY
