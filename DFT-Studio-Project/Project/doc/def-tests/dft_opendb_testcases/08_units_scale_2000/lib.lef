VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 2000 ;
END UNITS

MACRO U8A
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 200 BY 100 ;
  SYMMETRY X Y R90 ;
END U8A

MACRO U8B
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 60 BY 60 ;
  SYMMETRY X Y R90 ;
END U8B

END LIBRARY
