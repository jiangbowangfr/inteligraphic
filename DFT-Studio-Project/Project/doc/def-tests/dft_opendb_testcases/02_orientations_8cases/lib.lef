VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO MBIG
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 120 BY 60 ;
  SYMMETRY X Y R90 ;
END MBIG

MACRO MSMALL
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 30 BY 90 ;
  SYMMETRY X Y R90 ;
END MSMALL

END LIBRARY
