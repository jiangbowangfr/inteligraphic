VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO T10
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 30 BY 30 ;
  SYMMETRY X Y R90 ;
END T10

END LIBRARY
